# Keil uVision project CAP_Planar_DownScale.uvproj, settings and files
target CAP_Planar_DownScale (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: CAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\Driver\Include
  memory RVCT1: ROM 0x8000 size 0x70000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ./: main.c i2c_gpio.c sensor_nt99141.c sensor_nt99050.c
  group Libraries
    ../../Driver/Source/: sys.c cap.c retarget.c cache.c startup.s vector.s
