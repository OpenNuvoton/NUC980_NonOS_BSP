# Keil uVision project CRYPTO_RSA.uvproj, settings and files
target CRYPTO_RSA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: CRYPTO_RSA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\Driver\Include;..\..\ThirdParty\mbedtls-2.13.0\include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ./: main.c adc_rng.c
  group Libraries
    ../../Driver/Source/: sys.c cache.c retarget.c startup.s vector.s crypto.c etimer.c adc.c
  group MbedTLS
    ../../ThirdParty/mbedtls-2.13.0/library/: bignum.c aes.c aesni.c asn1parse.c ctr_drbg.c entropy.c entropy_poll.c md.c md_wrap.c md5.c oid.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c
