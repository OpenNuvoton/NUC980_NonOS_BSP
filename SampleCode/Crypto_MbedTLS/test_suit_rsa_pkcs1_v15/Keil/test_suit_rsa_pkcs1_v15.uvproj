# Keil uVision project test_suit_rsa_pkcs1_v15.uvproj, settings and files
target test_suit_rsa_pkcs1_v15 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: test_suit_rsa_pkcs1_v15
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\mbedtls-2.13.0\include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c vector_data.s
  group Libraries
    ../../../../Driver/Source/: cache.c crypto.c retarget.c sys.c startup.s vector.s
  group MbedTLS
    ../../../../ThirdParty/mbedtls-2.13.0/library/: aesni.c asn1parse.c bignum.c md.c md_wrap.c md5.c oid.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c platform_util.c
