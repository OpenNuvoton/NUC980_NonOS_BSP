# Keil uVision project EMAC_LwIP_httpd.uvproj, settings and files
target EMAC_LwIP_httpd (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: EMAC_LwIP_httpd
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=1295,177,550
  c include: ..\..\..\Driver\Include;..\lwip\include;..\..\..\ThirdParty\lwIP\src\include\ipv4;..\..\..\ThirdParty\lwIP\src\include\
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: sys.c retarget.c etimer.c startup.s vector.s cache.c
  group LwIP
    ../lwip/: sys_arch.c
    ../lwip/netif/: eth0.c eth1.c ethernetif.c
    ../../../ThirdParty/lwip/src/netif/: ethernet.c
    ../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c lwip_sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
