# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Driver\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC980;..\..\FreeRTOS
  asm include: ..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC980
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group Demo Files
    ../: main.c multithread.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM9_NUC980/: port.c portASM.s
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: BlockQ.c semtest.c PollQ.c
  group lib
    ../../../Driver/Source/: sys.c cache.c uart.c retarget.c startup.s vector.s
