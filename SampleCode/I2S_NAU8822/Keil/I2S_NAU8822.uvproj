# Keil uVision project I2S_NAU8822.uvproj, settings and files
target I2S_NAU8822 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: I2S_NAU8822
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c include: ..\..\..\Driver\Include
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: cache.c i2c.c i2s.c retarget.c startup.s sys.c vector.s
