# Keil uVision project PDMA_ScatterGather_PingPongBuffer.uvproj, settings and files
target PDMA_ScatterGather_PingPongBuffer (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: PDMA_ScatterGather_PingPongBuffer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Driver\Include
  memory RVCT1: ROM 0x8000 size 0x70000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c
  group Libraries
    ../../../Driver/Source/: sys.c cache.c retarget.c startup.s vector.s pdma.c
