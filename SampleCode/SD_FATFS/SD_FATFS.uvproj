# Keil uVision project SD_FATFS.uvproj, settings and files
target SD_FATFS (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: sd_fatfs
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1
  c include: ..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x70000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group User
    ./: main.c diskio.c SDGlue.c
  group Libraries
    ../../Driver/Source/: sys.c sdh.c cache.c retarget.c vector.s startup.s etimer.c
  group FATFS
    ../../ThirdParty/FatFs/src/: ff.c
