# Keil uVision project USBD_Mass_Storage_SRAM.uvproj, settings and files
target USBD_Mass_Storage_SRAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBD_Mass_Storage_SRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group User
    ./: main.c descriptors.c MassStorage.c
  group Libraries
    ../../Driver/Source/: sys.c usbd.c cache.c retarget.c startup.s vector.s
