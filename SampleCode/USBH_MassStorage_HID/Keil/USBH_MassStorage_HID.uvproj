# Keil uVision project USBH_MassStorage_HID.uvproj, settings and files
target USBH_MassStorage_HID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBH_MassStorage_HID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NO_TIMER
  c misc: --diag_suppress=4017
  c include: ..\..\..\Driver\Include;..\..\..\Library\UsbHostLib\inc;..\..\..\ThirdParty\FatFs\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c diskio.c
  group src_usb_core
    ../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c support.c usb_core.c
  group Libraries
    ../../../Driver/Source/: cache.c etimer.c retarget.c startup.s sys.c vector.s
  group src_msc
    ../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group src_fatfs
    ../../../ThirdParty/FatFs/src/: ff.c
  group src_hid
    ../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
