# Keil uVision project USBH_UAC_HID.uvproj, settings and files
target USBH_UAC_HID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBH_UAC_HID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NO_TIMER
  c misc: --diag_suppress=4017
  c include: ..\..\..\Driver\Include;..\..\..\Library\UsbHostLib\inc
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x2000000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group src
    ../: main.c
  group src_usb_core
    ../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c support.c usb_core.c
  group Libraries
    ../../../Driver/Source/: cache.c etimer.c retarget.c startup.s sys.c vector.s
  group src_hid
    ../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group src_uac
    ../../../Library/UsbHostLib/src_uac/: uac_core.c uac_driver.c uac_parser.c
