# Keil uVision project LwIP_TCP_EchoClient.uvproj, settings and files
target LwIP_TCP_EchoClient (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: LwIP_TCP_EchoClient +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\;..\..\..\Driver\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC980;..\..\FreeRTOS;..\..\..\ThirdParty\lwIP\src\include;..\..\lwIPShare\include
  asm include: ..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM9_NUC980
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\nuc980.sct
  link misc: --entry 0x8000
  group User
    ../: main.c tcp_echoclient-netconn.c multithread.c
    ../../lwIPShare/: sys_arch.c
    ../../lwIPShare/netif/: ethernetif.c eth0.c eth1.c
  group FreeRTOS
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM9_NUC980/: port.c portASM.s
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: BlockQ.c semtest.c PollQ.c GenQTest.c QueueSet.c
  group lib
    ../../../Driver/Source/: sys.c cache.c uart.c retarget.c startup.s vector.s
  group LwIP
    ../../../ThirdParty/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../ThirdParty/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../ThirdParty/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../ThirdParty/lwip/src/netif/: ethernet.c
